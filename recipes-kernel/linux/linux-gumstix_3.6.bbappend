FILESEXTRAPATHS_prepend := "${THISDIR}/linux-gumstix-3.6:"

# PRINC := "${@int(PRINC) + 1}"

SRC_URI += "file://defconfig"

