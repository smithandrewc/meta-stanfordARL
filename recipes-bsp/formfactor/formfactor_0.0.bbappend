FILESEXTRAPATHS_prepend_stanford-ARL := "${THISDIR}/${PN}:"

PRINC = "1"
