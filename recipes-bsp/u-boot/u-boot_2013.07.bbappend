FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

# PRINC := "${@int(PRINC) + 1}"

SRC_URI += "file://pin-mux-gpio70.patch"

